CORE_IMAGE_EXTRA_INSTALL += "copytofilesystem "

